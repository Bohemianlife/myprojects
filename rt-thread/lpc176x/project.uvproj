# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc
  c flags: Optim=1
  c include: applications;.;CMSIS\CM3\DeviceSupport\NXP\LPC17xx;F:/211/github/RT-Thread/rt-thread/components/CMSIS/Include;drivers\inc;F:/211/github/RT-Thread/rt-thread/components/init;Myapplications\inc;F:/211/github/RT-Thread/rt-thread/components/init;F:/211/github/RT-Thread/rt-thread/include;F:/211/github/RT-Thread/rt-thread/libcpu/arm/cortex-m3;F:/211/github/RT-Thread/rt-thread/libcpu/arm/common;F:/211/github/RT-Thread/rt-thread/components/finsh
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c platform.c startup.c
  group CMSIS
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Drivers
    drivers/: board.c button.c led.c spi.c uart.c
  group myapplication
    Myapplications/: mybutton.c myled.c
  group Kernel
    F:/211/github/RT-Thread/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    F:/211/github/RT-Thread/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    F:/211/github/RT-Thread/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    F:/211/github/RT-Thread/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
